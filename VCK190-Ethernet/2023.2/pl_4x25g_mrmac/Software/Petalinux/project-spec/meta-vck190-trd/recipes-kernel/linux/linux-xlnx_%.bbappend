

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
