SUMMARY = "Firmware for the vpk180-a01 versal system controller"

include sc-apps-firmware.inc

FW_DIR = "vpk180"

COMPATIBLE_MACHINE:eval_brd_sc = "${MACHINE}"

