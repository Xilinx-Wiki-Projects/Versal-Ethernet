SUMMARY = "Recipe to embedded rich Python Package"
HOMEPAGE ="https://pypi.org/project/rich"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b5f0b94fbc94f5ad9ae4efcf8a778303"

inherit pypi setuptools3

PYPI_PACKAGE = "rich"

SRC_URI[md5sum] = "40075240f82b1390749123e69624d9b6"
SRC_URI[sha256sum] = "14bfd0507edc633e021b02c45cbf7ca22e33b513817627b8de3412f047a3e798"

