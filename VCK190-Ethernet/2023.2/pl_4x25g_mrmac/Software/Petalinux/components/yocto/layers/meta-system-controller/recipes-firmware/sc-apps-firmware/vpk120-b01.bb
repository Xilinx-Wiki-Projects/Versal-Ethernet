SUMMARY = "Firmware for the vpk120-b01 versal system controller"

include sc-apps-firmware.inc

FW_DIR = "vpk120"

COMPATIBLE_MACHINE:eval_brd_sc = "${MACHINE}"

