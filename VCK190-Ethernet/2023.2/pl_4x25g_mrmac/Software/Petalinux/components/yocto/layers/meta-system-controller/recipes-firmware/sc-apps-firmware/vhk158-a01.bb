SUMMARY = "Firmware for the vhk158-a01 versal system controller"

include sc-apps-firmware.inc

FW_DIR = "vhk158"

COMPATIBLE_MACHINE:eval_brd_sc = "${MACHINE}"

